Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2019-04-17T18:06:12
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Apr 17 18:06:12 2019 * Host: DEGTL09122 * Database: C:\Users\deschvi\AppData\Local\Temp\{75B375ED-4F3E-49C5-B99A-DD19B4C1CDF8}\ifc * Database version: 5507 * Database creation date: Wed Apr 17 18:06:10 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Apr 17 18:06:11 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Apr 17 18:06:11 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 23744044_D_11106520_DGM7440_EDST-CLST, 11106520_D_DGM7440_EDST-CLST:23744044_D_11106520_DGM7440_EDST-CLST:205683
In: Level 1
Type - Classification: DGM7000 (Uniformat); Material: z_Miele_Design_Zinc_Steel, z_Miele_Connection_Electric, z_Miele_Design_Steel_Chrom, z_Miele_Design_OBSW, z_Miele_Design_CLST
Pset_BuildingElementProxyCommon - Reference: 23744044_D_11106520_DGM7440_EDST-CLST
Pset_ManufacturerTypeInformation - Manufacturer: Miele
